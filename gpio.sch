File: gpio.sch (KiCad schematic (older format))
At the start: 5 parts, among them J1 CONN_02X20, J2 CONN_02X20, U1 LFE5U-85F-6BG381C

Commit message: Removind ADC and right connector
Parts:
- removed J2: CONN_02X20, Socket_Strips:Socket_Strip_Angled_2x20, symbol Connector_Generic:Conn_02x20_Odd_Even
Connections:
- net labels removed: +3V3, IN5V, OUT5V
- wire segments 24 -> 12
Other:
- note removed: "14"
- note removed: "15"
- note removed: "16"
- note removed: "17"
- note removed: "18"
- note removed: "19"
- note removed: "20"
- note removed: "21"
- note removed: "22"
- note removed: "23"
- note removed: "24"
- note removed: "25"
- note removed: "26"
- note removed: "27"
- moved on the sheet: D51, D52

Commit message: More removing
Parts:
- removed J1: CONN_02X20, Socket_Strips:Socket_Strip_Angled_2x20, symbol Connector_Generic:Conn_02x20_Odd_Even
Connections:
- net labels removed: 2V5_3V3, GND
- wire segments 12 -> 0
Changed lines of the file:
@@
 $EndComp
-$Comp
-L Connector_Generic:Conn_02x20_Odd_Even J1
-U 1 1 58E6B835
-P 1950 4550
-F 0 "J1" H 2000 5550 50  0000 C CNN
-F 1 "CONN_02X20" H 2000 3450 50  0000 C CNN
-F 2 "Socket_Strips:Socket_Strip_Angled_2x20" H 1950 3600 50  0001 C CNN
-F 3 "" H 1950 3600 50  0000 C CNN
-F 4 "Leave empty" H 1950 4550 60  0001 C CNN "Note"
-	1    1950 4550
-	-1   0    0    -1
-$EndComp
-Wire Wire Line
-	2700 5550 2150 5550
-Wire Wire Line
-	1650 5550 1150 5550
-$Comp
-L power:GND #PWR05
-U 1 1 58E710CC
-P 2550 3750
-F 0 "#PWR05" H 2550 3500 50  0001 C CNN
-F 1 "GND" H 2550 3600 50  0000 C CNN
-F 2 "" H 2550 3750 60  0000 C CNN
-F 3 "" H 2550 3750 60  0000 C CNN
-	1    2550 3750
-	0    -1   1    0
-$EndComp
-$Comp
-L power:GND #PWR06
-U 1 1 58E710E6
-P 2550 4650
-F 0 "#PWR06" H 2550 4400 50  0001 C CNN
-F 1 "GND" H 2550 4500 50  0000 C CNN
-F 2 "" H 2550 4650 60  0000 C CNN
-F 3 "" H 2550 4650 60  0000 C CNN
-	1    2550 4650
-	0    -1   1    0
-$EndComp
-$Comp
-L power:GND #PWR07
-U 1 1 58E710F2
-P 2550 5450
-F 0 "#PWR07" H 2550 5200 50  0001 C CNN
-F 1 "GND" H 2550 5300 50  0000 C CNN
-F 2 "" H 2550 5450 60  0000 C CNN
-F 3 "" H 2550 5450 60  0000 C CNN
-	1    2550 5450
-	0    -1   1    0
-$EndComp
-Wire Wire Line
-	2550 3750 2150 3750
-Wire Wire Line
-	2150 3650 2700 3650
-Wire Wire Line
-	2550 4650 2150 4650
-Wire Wire Line
-	2700 4550 2150 4550
-Wire Wire Line
-	2550 5450 2150 5450
-$Comp
-L power:GND #PWR010
-U 1 1 58E7117D
-P 1200 3750
-F 0 "#PWR010" H 1200 3500 50  0001 C CNN
-F 1 "GND" H 1200 3600 50  0000 C CNN
-F 2 "" H 1200 3750 60  0000 C CNN
-F 3 "" H 1200 3750 60  0000 C CNN
-	1    1200 3750
-	0    1    1    0
-$EndComp
-$Comp
-L power:GND #PWR08
-U 1 1 58E71197
-P 1250 4650
-F 0 "#PWR08" H 1250 4400 50  0001 C CNN
-F 1 "GND" H 1250 4500 50  0000 C CNN
-F 2 "" H 1250 4650 60  0000 C CNN
-F 3 "" H 1250 4650 60  0000 C CNN
-	1    1250 4650
-	0    1    1    0
-$EndComp
-$Comp
-L power:GND #PWR09
-U 1 1 58E711A3
-P 1250 5450
-F 0 "#PWR09" H 1250 5200 50  0001 C CNN
-F 1 "GND" H 1250 5300 50  0000 C CNN
-F 2 "" H 1250 5450 60  0000 C CNN
-F 3 "" H 1250 5450 60  0000 C CNN
-	1    1250 5450
-	0    1    1    0
-$EndComp
-Wire Wire Line
-	1200 3750 1650 3750
-Wire Wire Line
-	1650 3650 1050 3650
-Wire Wire Line
-	1250 4650 1650 4650
-Wire Wire Line
-	1650 4550 1100 4550
-Wire Wire Line
-	1650 5450 1250 5450
 $Comp
 L power:+5V #PWR022
@@
 Text GLabel 2150 4450 2    60   Input ~ 0
 GN6
-Text GLabel 1650 4450 0    60   Input ~ 0
-GP6
 Text GLabel 2150 4750 2    60   Input ~ 0
 GN7
@@
 Text Notes 6750 2250 0    60   ~ 0
 NC v1.7
-Text GLabel 2700 3650 2    60   Input ~ 0
-2V5_3V3
-Text GLabel 2700 4550 2    60   Input ~ 0
-2V5_3V3
-Text GLabel 2700 5550 2    60   Input ~ 0
-2V5_3V3
-Text GLabel 1150 5550 0    60   Input ~ 0
-2V5_3V3
-Text GLabel 1100 4550 0    60   Input ~ 0
-2V5_3V3
-Text GLabel 1050 3650 0    60   Input ~ 0
-2V5_3V3
 Wire Notes Line
 	9250 3450 9150 3450
@@
 Text GLabel 9900 5250 2    60   Input ~ 0
 GP14
+Text GLabel 1650 4450 0    60   Input ~ 0
+GP6
 $EndSCHEMATC

Commit message: More removal, spliting modules
Parts:
- removed D51, D52: 0, jumper:D_SMA_Jumper_NC, symbol Device:Jumper_NC_Small
Changed lines of the file:
@@
 $EndDescr
-$Comp
-L Device:Jumper_NC_Small D51
-U 1 1 56AC483B
-P 9100 3600
-F 0 "D51" H 9100 3700 50  0000 C CNN
-F 1 "0" H 9100 3550 50  0000 C CNN
-F 2 "jumper:D_SMA_Jumper_NC" V 9100 3600 60  0001 C CNN
-F 3 "" V 9100 3600 60  0000 C CNN
-F 4 "Leave empty" H 9100 3600 50  0001 C CNN "Note"
-	1    9100 3600
-	1    0    0    1
-$EndComp
-$Comp
-L Device:Jumper_NC_Small D52
-U 1 1 56AC4846
-P 10000 3600
-F 0 "D52" H 10000 3700 50  0000 C CNN
-F 1 "0" H 10000 3550 50  0000 C CNN
-F 2 "jumper:D_SMA_Jumper_NC" V 10000 3600 60  0001 C CNN
-F 3 "" V 10000 3600 60  0000 C CNN
-F 4 "Leave empty" H 10000 3600 50  0001 C CNN "Note"
-	1    10000 3600
-	1    0    0    1
-$EndComp
 $Comp
 L power:+5V #PWR011

Commit message: Adding footprints
Parts:
- added J1, J2: DF40C-100DP-0.4V(51), connectors:HRS_DF40C-100DP-0.4V(51), symbol DF40C-100DP-0.4V_51_:DF40C-100DP-0.4V(51)
Connections:
- net +5V: now also J1.77, J1.79, J1.81, J1.83, J1.85, J1.87
- new net AnalogIP0: J1.96
- new net AnalogIP1: J1.94
- new net BT_nDisable: J1.91
- new net CAM0_C_N: J2.40
- new net CAM0_C_P: J2.42
- new net CAM0_D0_N: J2.28
- new net CAM0_D0_P: J2.30
- new net CAM0_D1_N: J2.34
- new net CAM0_D1_P: J2.36
- new net CAM1_C_N: J2.27
- new net CAM1_C_P: J2.29
- new net CAM1_D0_N: J2.15
- new net CAM1_D0_P: J2.17
- new net CAM1_D1_N: J2.21
- new net CAM1_D1_P: J2.23
- new net CAM1_D2_N: J2.33
- new net CAM1_D2_P: J2.35
- new net CAM1_D3_N: J2.39
- new net CAM1_D3_P: J2.41
- new net CM4_1.8V: J1.88, J1.90
- new net CM4_3.3V: J1.84, J1.86
- new net Camera_GPIO: J1.97
- new net DSI0_C_N: J2.69
- new net DSI0_C_P: J2.71
- new net DSI0_D0_N: J2.57
- new net DSI0_D0_P: J2.59
- new net DSI0_D1_N: J2.63
- new net DSI0_D1_P: J2.65
- new net DSI1_C_N: J2.87
- new net DSI1_C_P: J2.89
- new net DSI1_D0_N: J2.75
- new net DSI1_D0_P: J2.77
- new net DSI1_D1_N: J2.81
- new net DSI1_D1_P: J2.83
- new net DSI1_D2_N: J2.93
- new net DSI1_D2_P: J2.95
- new net DSI1_D3_N: J2.94
- new net DSI1_D3_P: J2.96
- new net EEPROM_nWP: J1.20
- new net ETH_0N: J1.10
- new net ETH_0P: J1.12
- new net ETH_1N: J1.6
- new net ETH_1P: J1.4
- new net ETH_2N: J1.9
- new net ETH_2P: J1.11
- new net ETH_3N: J1.5
- new net ETH_3P: J1.3
- new net ETH_SYNC_IN: J1.16
- new net ETH_SYNC_OUT: J1.18
- new net ETH_nLED1: J1.19
- new net ETH_nLED2: J1.17
- new net ETH_nLED3: J1.15
- new net GLOBAL_EN: J1.99
- new net GND: J1.1, J1.13, J1.14, J1.2, J1.22, J1.23, J1.32, J1.33, J1.42, J1.43, J1.52, J1.53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
- new net GPIO10: J1.44
- new net GPIO11: J1.38
- new net GPIO12: J1.31
- new net GPIO13: J1.28
- new net GPIO14: J1.55
- new net GPIO15: J1.51
- new net GPIO16: J1.29
- new net GPIO17: J1.50
- new net GPIO18: J1.49
- new net GPIO19: J1.26
- new net GPIO2: J1.58
- new net GPIO20: J1.27
- new net GPIO21: J1.25
- new net GPIO22: J1.46
- new net GPIO23: J1.47
- new net GPIO24: J1.45
- new net GPIO25: J1.41
- new net GPIO26: J1.24
- new net GPIO27: J1.48
- new net GPIO3: J1.56
- new net GPIO4: J1.54
- new net GPIO5: J1.34
- new net GPIO6: J1.30
- new net GPIO7: J1.37
- new net GPIO8: J1.39
- new net GPIO9: J1.40
- new net GPIO_VREF: J1.78
- new net HDMI0_CEC: J2.51
- new net HDMI0_CLK_N: J2.90
- new net HDMI0_CLK_P: J2.88
- new net HDMI0_HOTPLUG: J2.53
- new net HDMI0_SCL: J2.100
- new net HDMI0_SDA: J2.99
- new net HDMI0_TX0_N: J2.84
- new net HDMI0_TX0_P: J2.82
- new net HDMI0_TX1_N: J2.78
- new net HDMI0_TX1_P: J2.76
- new net HDMI0_TX2_N: J2.72
- new net HDMI0_TX2_P: J2.70
- new net HDMI1_CEC: J2.49
- new net HDMI1_CLK_N: J2.66
- new net HDMI1_CLK_P: J2.64
- new net HDMI1_HOTPLUG: J2.43
- new net HDMI1_SCL: J2.47
- new net HDMI1_SDA: J2.45
- new net HDMI1_TX0_N: J2.60
- new net HDMI1_TX0_P: J2.58
- new net HDMI1_TX1_N: J2.54
- new net HDMI1_TX1_P: J2.52
- new net HDMI1_TX2_N: J2.48
- new net HDMI1_TX2_P: J2.46
- new net ID_SC: J1.35
- new net ID_SD: J1.36
- new net PCIe_CLK_N: J2.12
- new net PCIe_CLK_P: J2.10
- new net PCIe_CLK_nREQ: J2.2
- new net PCIe_RX_N: J2.18
- new net PCIe_RX_P: J2.16
- new net PCIe_TX_N: J2.24
- new net PCIe_TX_P: J2.22
- new net PCIe_nRST: J2.9
- new net PI_LED_nPWR: J1.95
- new net Pi_nLED_Activity: J1.21
- new net RUN_PG: J1.92
- new net Reserved: J1.76, J2.4, J2.6
- new net SCL0: J1.80
- new net SDA0: J1.82
- new net SD_CLK: J1.57
- new net SD_CMD: J1.62
- new net SD_DAT0: J1.63
- new net SD_DAT1: J1.67
- new net SD_DAT2: J1.69
- new net SD_DAT3: J1.61
- new net SD_DAT4: J1.68
- new net SD_DAT5: J1.64
- new net SD_DAT6: J1.72
- new net SD_DAT7: J1.70
- new net SD_PWR_ON: J1.75
- new net SD_VDD_Override: J1.73
- new net USB_N: J2.3
- new net USB_OTG_ID: J2.1
- new net USB_P: J2.5
- new net VDAC_COMP: J2.11
- new net WL_nDisable: J1.89
- new net nEXTRST: J1.100
- new net nRPIBOOT: J1.93
Other:
- note removed: "NC <v3.1.2"
- note removed: "NC v1.7"
- moved on the sheet: U1A, U1F

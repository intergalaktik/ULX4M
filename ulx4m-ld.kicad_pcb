# Repository intergalaktik/ULX4M

File README.md:

<!--
SPDX-FileCopyrightText: 2016 2016 Goran Mahovlic, <goran.mahovlic@gmail.com> et al.

SPDX-License-Identifier: CERN-OHL-S-2.0
-->

# ULX4M-LS PCB

[ULX4M] = University digital Logic Learning Xtensible board release 4 Moduler successor of [ULX3S](http://radiona.org/ulx3s) = [University digital Logic](https://www.fer.unizg.hr/en/course/diglog) Learning
Xtensible board release 3 with SDRAM,
Successor of [ULX2S](http://github.com/emard/ulx2s).

### 3D preview

### Panel

[Schematics](/doc/schematics.pdf) and PCB KiCAD 5 PCB editor:

    kicad ulx4m.pro

## Features

FPGA: Lattice ECP5 [LFE5U-12F-6BG381C](http://www.latticesemi.com/~/media/LatticeSemi/Documents/DataSheets/ECP5/FPGA-DS-02012.pdf?document_id=50461) (12/25/45/85K LUT)

### Main parts

LFE5U-12F-6BG381C

IS42S16160G-7BL 32 MB SDRAM 

W25Q128JVSIM NOR Flash spiFlash, 3V, 128M-bit, 4Kb Uniform Sector

Ethernet - LAN8720A

### Programming options

External JTAG programming connector

JTAG connected to GPIO (programming with FTDI or ESP32)

USB (bootloader)

### Periferals

- [x] 2 lane CSI camera port  CAM0 and CAM1

- [x] 2 lane DSI display port DISP0 (fake differential)

- [x] DISP0 pins connected to DISP1

- [x] * SerDes pair (TX/RX) connected to 2.0 header (radio experiments)

- [x] True differential GPDI video output

- [x] Fake differential GPDI video output

- [x] 4 bit SD card connection

- [x] * SerDes connected to PCIe 1x 

- [x] * 2x SerDes pairs connected over capacitors to connector

- [x] GPIOs

- [x] 3 Buttons

- [x] 2 DIP SW

- [x] 8 LEDs

* Only available if ECP5 SerDes chip is used

### ULX4M on TOFU carrier board

## References

https://github.com/gatecat/TrellisBoard

https://github.com/orangecrab-fpga/orangecrab-hardware

https://github.com/antmicro/ecp5-dc-scm

https://github.com/butterstick-fpga/butterstick-hardware

## Work on this board is financed by NLnet foundation

https://nlnet.nl/project/ULX3M/

## Check up our blogposts

https://intergalaktik.eu/news/ulx4s-v0-0-1

https://intergalaktik.eu/news/ulx4s-v0-0-2

https://intergalaktik.eu/news/blending-ulx4m-nlnet-funded-fpga-board

https://intergalaktik.eu/news/production-testing-automation-for-ulx3s

https://intergalaktik.eu/news/blending-ulx4m-ls-v002

## Contact us

Discord: https://discord.gg/qwMUk6W

Gitter: https://gitter.im/ulx3s/Lobby

Mail: warp@intergalaktik.eu

Twitter: https://twitter.com/intergalaktikEU

## KiCad design ulx4m-ld.kicad_pcb

Board: 6 copper layers, 55.6 x 40.6 mm, 271 parts (177 on the bottom side), 297 nets.

Parts:
1.1V_1: 1.1V; TestPoint_Pad_1.0x1.0mm
BTN1, BTN2, BTN3: SW_Push; Switch_EVPAA
C1, C3, C4, C5, C7, C8, C9, C11, C12, C76, C95, C96: 22uF; C_0603_1608Metric
C2, C6, C10, C77: 100pF; C_0402_1005Metric
C13, C14, C15, C18, C21, C25, C26, C27, C28, C29, C39: 22nF; C_0402_1005Metric
C16, C17, C19, C20, C22, C23, C24, C38, C54, C97, C98: 2.2uF; C_0603_1608Metric
C30, C31, C32, C33, C34, C35, C36, C37, C40, C41, C42, C43, C44, C45, C46, C47, C88, C93, C94, C101, C122: 100n; C_0402_1005Metric
C48, C49, C50, C51, C52, C53: 22nF; C_0603_1608Metric
C55, C56, C57, C58, C59, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75: 22n; C_0402_1005Metric
C79, C80, C81, C82, C83, C84, C85, C86, C87, C89, C90, C91, C92, C100, C102, C103, C107, C118: 470n; C_0402_1005Metric
C99, C105, C109, C117, C120: 4u7; C_0402_1005Metric
C104, C106, C108, C110, C111, C112, C113, C114, C115, C116, C119, C121, C123, C124: 10n; C_0402_1005Metric
C125, C126, C127, C128: 22n; C_0201_0603Metric
D0, D4: RED; LED_0603_1608Metric
D1, D5: ORANGE; LED_0603_1608Metric
D2, D6: GREEN; LED_0603_1608Metric
D3, D7: BLUE; LED_0603_1608Metric
D8, D9: 3.6V; D_SOD-323_HandSoldering
D10, D11, D12, D13, D29: 1N914; D_SOD-323
FB1, FB2, FB3: BLM18PG121SN1D; L_0603_1608Metric
FI1, FI2, FI3, FI4, FI5, FI6: Fi; Fiducial_0.5mm_Mask1mm
H1, H2, H3, H4: HOLE; MountingHole_3.2mm_M3_ISO14580_Pad
J1, J2: DF40C-100DP-0.4V(51); HRS_DF40C-100DP-0.4V(51)
J3: JTAG; PinHeader_2x03_P1.00mm_Vertical_SMD
J4: Antenna; PinHeader_1x04_P2.54mm_Vertical
L1, L2, L3, L4: 2.2uH; L_1008_1210
P1: USB_OTG; USB-MICRO-B-FCI-10118192-0001LF
R1, R2: 27R; R_0402_1005Metric
R4, R6, R29, R68, R69: 1k; R_0402_1005Metric
R5, R7, R8, R9, R11, R12, R16, R17, R27, R28, R31, R32, R33: 15k; R_0402_1005Metric
R10, R13, R14, R15, R19, R20, R30, R58, R71: 4k7; R_0402_1005Metric
R18, R21, R22, R23, R24, R25, R26, R34, R35, R36, R37, R38, R40, R41, R42, R43, R44, R45, R46, R47, R70: 300; R_0402_1005Metric
R39, R48, R49, R50, R51, R52, R82, R83: 70; R_0402_1005Metric
R65: 12k1; R_0402_1005Metric
R72, R73, R74, R75, R76, R77, R84, R85, R86, R87: 10k2; R_0402_1005Metric
R81: 240R; R_0402_1005Metric
RA1, RA2, RA3, RA4: 15k; R_0402_1005Metric
RB1: 18k; R_0402_1005Metric
RB2: 4k7; R_0402_1005Metric
RB3: 3k3; R_0402_1005Metric
RB4: 12k; R_0402_1005Metric
RC1: *DNP; R_0402_1005Metric
RC2: 91k; R_0402_1005Metric
RP1, RP2, RP3, RP4: 0; R_0805_2012Metric_Pad1.29x1.40mm_HandSolder_Jumper_NC
RV2, RV3: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_DIP_x02; SW_DIP_SPSTx02_Slide_Copal_CVS-02xB_W5.9mm_P1mm
TP_1V35: 1V35; Testpoint_smd_1mm
TP_C16: C16; Testpoint_smd_1mm
TP_D8: D8; Testpoint_smd_1mm
TP_D16: D16; Testpoint_smd_1mm
TP_E8: E8; Testpoint_smd_1mm
TP_E9: E9; Testpoint_smd_1mm
U1: LFE5U-85F-6BG381C; BGA-381_pitch0.8mm_dia0.4mm
U2: AS4C256M16D3; BGA-96_9.0x13.0mm_Layout2x3x16_P0.8mm
U3: IS25LP128F-JBLE; SOA008-150-208mil
U4: KSZ9031RNXCA; QFN-48-Microchip-QFN77-48LD-PL-2
U5, U6, U7, U8: TLV62569DBV; TSOT-25
Y1: FNETHE025; Crystal_SMD_TXC_7M-4Pin_3.2x2.5mm
Y2: ASEMB-25.000MHZ-LC-T; OSC_ASEM1-16.000MHZ-LC-T
radiona: radiona

Connections:
2V5_3V3: C26.1, C38.1, C48.1, C49.1, C53.1, RV2.2, RV3.1, U1.F9 (VCCio0), U1.F10 (VCCio0), U1.H6 (VCCio7), U1.H7 (VCCio7), U1.J6 (VCCio7)
+2V5: C19.1, C29.1, C39.1, RP2.2, RV2.1, U1.F6 (VCCAUX), U1.F15 (VCCAUX), U1.P6 (VCCAUX), U1.P15 (VCCAUX), U1.V10 (VCCAUXA0), U1.V11 (VCCAUXA0), U1.V17 (VCCAUXA1), U1.V18 (VCCAUXA1)
+5V: C1.1, C5.1, C9.1, C76.1, J1.77, J1.79, J1.81, J1.83, J1.85, J1.87, P1.1 (VBUS), R10.1, R13.1, R14.1, R15.1, U5.1 (EN), U5.4 (VIN), U6.1 (EN), U6.4 (VIN), U7.1 (EN), U7.4 (VIN), U8.1 (EN), U8.4 (VIN)
/blinkey/ALED0: D0.2 (A), R40.2
/blinkey/ALED1: D1.2 (A), R41.2
/blinkey/ALED2: D2.2 (A), R42.2
/blinkey/ALED3: D3.2 (A), R43.2
/blinkey/ALED4: D4.2 (A), R44.2
/blinkey/ALED5: D5.2 (A), R45.2
/blinkey/ALED6: D6.2 (A), R46.2
/blinkey/ALED7: D7.2 (A), R47.2
/ethernet/AVDDL: C117.1, C118.1, C119.1, C121.1, FB2.1, U4.4 (AVDDL), U4.9 (AVDDL)
/ethernet/AVDDL_PLL: C120.1, C122.1, C123.1, FB3.1, U4.44 (AVDDL_PLL)
/ethernet/PHY_CLK: U4.46 (XI), Y2.3 (OUT)
/flash/FLASH_MISO: R28.2, U1.V2 (D1/MISO), U3.2 (MISO)
/flash/FLASH_MOSI: R27.2, U1.W2 (D0/MOSI), U3.5 (MOSI)
/flash/FLASH_SCK: R29.2, U1.U3 (CCLK), U3.6 (SCK)
/flash/FLASH_nCS: R30.2, U1.R2 (CSSPIN), U3.1 (~CS)
/flash/FLASH_nHOLD: R12.2, U1.W1 (D3/HOLDn), U3.7 (~HOLD)
/flash/FLASH_nWP: R11.2, U1.Y2 (D2/WPn), U3.3 (~WP)
/flash/FPGA_DONE: R32.2, U1.Y3 (DONE)
/flash/FPGA_INITN: R33.2, U1.V3 (INITn)
/flash/FPGA_PROGRAMN: D29.2 (A), R31.2, U1.W3 (PROGRAMn)
/gpio/CAM0_D0_LP: R21.2, U1.B5 (PL11C)
/power/FB1: C2.2, RA1.2, RB1.2, RC1.2, U5.5 (FB)
/power/FB2: C10.2, RA2.2, RB2.2, U6.5 (FB)
/power/FB3: C6.2, RA3.2, RB3.2, U7.5 (FB)
/power/FB4: C77.2, RA4.2, RB4.2, U8.5 (FB)
/power/L1: L1.1, U5.3 (LX)
/power/L2: L2.1, U6.3 (LX)
/power/L3: L3.1, U7.3 (LX)
/power/L4: L4.1, U8.3 (LX)
/power/P1V1: C2.1, C3.1, C4.1, C22.1, L1.2, RA1.1, RP1.1
/power/P1V35: C77.1, C95.1, C96.1, C97.1, L4.2, RA4.1, RP4.1
/power/P2V5: C10.1, C11.1, C12.1, C23.1, L2.2, RA2.1, RP2.1
/power/P3V3: C6.1, C7.1, C8.1, C24.1, L3.2, RA3.1, RP3.1
/serdes/1N: C125.1, J4.1
/serdes/1P: C126.1, J4.2
/serdes/2N: C127.1, J4.3
/serdes/2P: C128.1, J4.4
/serdes/CLK_0_N: C66.1, U1.Y12 (REFCLKN_D0)
/serdes/CLK_0_P: C59.2, U1.Y11 (REFCLKP_D0)
/serdes/CLK_1_N: C69.1, U1.W20 (REFCLKN_D1)
/serdes/CLK_1_P: C63.2, U1.Y19 (REFCLKP_D1)
/serdes/S_0_N: C67.1, U1.Y6 (HDRXN0_D0CH0)
/serdes/S_0_P: C61.2, U1.Y5 (HDRXP0_D0CH0)
/serdes/S_1_N: C68.1, U1.Y8 (HDRXN0_D0CH1)
/serdes/S_1_P: C62.2, U1.Y7 (HDRXP0_D0CH1)
/serdes/S_2_N: C72.1, U1.W5 (HDTXN0_D0CH0)
/serdes/S_2_P: C55.2, U1.W4 (HDTXP0_D0CH0)
/serdes/S_3_N: C73.1, U1.W9 (HDTXN0_D0CH1)
/serdes/S_3_P: C56.2, U1.W8 (HDTXP0_D0CH1)
/serdes/S_4_N: C70.1, U1.Y15 (HDRXN0_D1CH0)
/serdes/S_4_P: C64.2, U1.Y14 (HDRXP0_D1CH0)
/serdes/S_5_N: C71.1, C127.2, U1.Y17 (HDRXN0_D1CH1)
/serdes/S_5_P: C65.2, C128.2, U1.Y16 (HDRXP0_D1CH1)
/serdes/S_6_N: C74.1, U1.W14 (HDTXN0_D1CH0)
/serdes/S_6_P: C57.2, U1.W13 (HDTXP0_D1CH0)
/serdes/S_7_N: C75.1, C125.2, U1.W18 (HDTXN0_D1CH1)
/serdes/S_7_P: C58.2, C126.2, U1.W17 (HDTXP0_D1CH1)
BTN1: BTN1.2, U1.E1 (PL38D)
BTN2: BTN2.2, U1.D2 (PL38C)
BTN3: BTN3.2, U1.F1 (PCLKC6_1)
CAM0_C_N: J2.40, U1.E2 (PCLKC7_0)
CAM0_C_P: J2.42, U1.F2 (PCLKT7_0)
CAM0_D0_N: J2.28, U1.A5 (PL11B)
CAM0_D0_P: J2.30, R21.1, U1.A4 (PL11A)
CAM0_D1_N: J2.34, U1.B1 (PL35B)
CAM0_D1_P: J2.36, U1.A2 (PL35A)
CAM1_C_N: J2.27, U1.F3 (PCLKC7_1)
CAM1_C_P: J2.29, U1.G3 (PCLKT7_1)
CAM1_D0_N: J2.15, U1.B4 (PL14B)
CAM1_D0_P: J2.17, U1.C4 (PL14A)
CAM1_D1_N: J2.21, U1.D5 (PL17B)
CAM1_D1_P: J2.23, U1.E4 (PL17A)
CLK_25MHz: U1.G2 (PCLKT6_1), Y1.3
CM4_1.8V: J1.88, J1.90
CM4_3.3V: C14.1, C15.1, C16.1, C18.1, C20.1, C21.1, C50.1, C51.1, C52.1, C54.1, C105.1, C107.1, C110.1, C113.1, C116.1, C124.1, FB1.1, J1.84, J1.86, J3.2, R8.1, R11.1, R12.1, R16.1, R18.2, R19.2, R20.2, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R58.1, R70.1, R72.2, R73.2, R74.2, R75.2, R76.2, R77.2, R84.2, R85.2, R86.2, R87.2, RP3.2, RV3.2, U1.F11 (VCCio1), U1.F12 (VCCio1), U1.L6 (VCCio6), U1.L7 (VCCio6), U1.M6 (VCCio6), U1.P9 (VCCio8), U1.P10 (VCCio8), U1.T2 (SN/CSn), U1.T3 (WRITEn), U1.T4 (CFG_1), U1.U2 (CS1n), U3.8 (VCC), U4.16 (DVDDH), U4.34 (DVDDH), U4.40 (DVDDH), Y1.1, Y1.4, Y2.1 (STDB), Y2.4 (VDD)
Camera_GPIO: J1.97, U1.A17 (PT116A)
DDR3_A0: U1.F18 (PR14D), U2.N3 (A0)
DDR3_A1: U1.L17 (PR50B), U2.P7 (A1)
DDR3_A2: U1.D19 (PR35B), U2.P3 (A2)
DDR3_A3: U1.E18 (PR14C), U2.N2 (A3)
DDR3_A4: U1.H16 (PR17D), U2.P8 (A4)
DDR3_A5: U1.T20 (PR86C), U2.P2 (A5)
DDR3_A6: U1.U17 (PR92B), U2.R8 (A6)
DDR3_A7: U1.T17 (GPLL0C_IN), U2.R2 (A7)
DDR3_A8: U1.E16 (PR11C), U2.T8 (A8)
DDR3_A9: U1.U19 (PR89C), U2.R3 (A9)
DDR3_A10: U1.J17 (PR20C), U2.L7 (A10/AP)
DDR3_A11: U1.J16 (PR20D), U2.R7 (A11)
DDR3_A12: U1.P17 (PR53D), U2.N7 (A12/~BC)
DDR3_A13: U1.U20 (PR86D), U2.T3 (A13)
DDR3_A14: U1.N20 (PR83B), U2.T7 (A14)
DDR3_A15: U1.P18 (PR83D), U2.M7 (NC/A15)
DDR3_BA0: U1.P19 (PR83C), U2.M2 (BA0)
DDR3_BA1: U1.G16 (PR17C), U2.N8 (BA1)
DDR3_BA2: U1.P20 (PR86A), U2.M3 (BA2)
DDR3_CAS: U1.F20 (PR38C), U2.K3 (~CAS)
DDR3_CKE: U1.N19 (PR83A), U2.K9 (CKE)
DDR3_CLK+: R82.1, U1.L20 (PCLKT3_1), U2.J7 (CK+)
DDR3_CLK-: R83.2, U1.M20 (PCLKC3_1), U2.K7 (CK-)
DDR3_CS: U1.H18 (PR20A), U2.L2 (~CS)
DDR3_DM0: U1.F16 (PR11D), U2.E7 (LDM)
DDR3_DM1: U1.U16 (GPLL0T_IN), U2.D3 (UDM)
DDR3_DQ0: U1.R17 (PR56D), U2.E3 (DQ0)
DDR3_DQ1: U1.L19 (PCLKT3_0), U2.F7 (DQ1)
DDR3_DQ2: U1.R16 (PR56C), U2.F2 (DQ2)
DDR3_DQ3: U1.L16 (GR_PCLK3_0), U2.F8 (DQ3)
DDR3_DQ4: U1.M18 (PR50D), U2.H3 (DQ4)
DDR3_DQ5: U1.M19 (PCLKC3_0), U2.H8 (DQ5)
DDR3_DQ6: U1.N18 (PR53C), U2.G2 (DQ6)
DDR3_DQ7: U1.N17 (PR56A), U2.H7 (DQ7)
DDR3_DQ8: U1.J19 (PCLKT2_1), U2.D7 (DQ8)
DDR3_DQ9: U1.C20 (PR35A), U2.C3 (DQ9)
DDR3_DQ10: U1.F19 (PR38B), U2.C8 (DQ10)
DDR3_DQ11: U1.E20 (PR38A), U2.C2 (DQ11)
DDR3_DQ12: U1.J18 (GR_PCLK2_0), U2.A7 (DQ12)
DDR3_DQ13: U1.K19 (PCLKC2_1), U2.A2 (DQ13)
DDR3_DQ14: U1.E19 (PR35D), U2.B8 (DQ14)
DDR3_DQ15: U1.G20 (PR38D), U2.A3 (DQ15)
DDR3_DQS0+: U1.N16 (PR53A), U2.F3 (LDQS+)
DDR3_DQS0-: U1.M17 (PR53B), U2.G3 (LDQS-)
DDR3_DQS1+: U1.G19 (GR_PCLK2_1), U2.C7 (UDQS+)
DDR3_DQS1-: U1.H20 (PR41B), U2.B7 (UDQS-)
DDR3_ODT: U1.T19 (PR89A), U2.K1 (ODT)
DDR3_RAS: U1.R20 (PR86B), U2.J3 (~RAS)
DDR3_RESET: U1.T18 (PR89D), U2.T2 (~RESET)
DDR3_VREF: C88.1, C93.1, R68.2, R69.1, U1.D20 (VREF1_2), U1.P16 (VREF1_3), U2.H1 (VrefDQ), U2.M8 (VrefCA)
DDR3_WE: U1.H17 (PR20B), U2.L3 (~WE)
DSI0_C_N: J2.69, R38.2, R39.1
DSI0_C_P: J2.71, R26.1, R49.1
DSI0_D0_N: J2.57, R37.2, R51.1
DSI0_D0_P: J2.59, R25.1, R50.1
DSI0_D1_N: J2.63, R36.2, R48.1
DSI0_D1_P: J2.65, R24.1, R52.1
DSI1_C_N: C69.2, J2.87
DSI1_C_P: C63.1, J2.89
DSI1_D0_N: C71.2, J2.75
DSI1_D0_P: C65.1, J2.77
DSI1_D1_N: C75.2, J2.81
DSI1_D1_P: C58.1, J2.83
DSI1_D2_N: J2.93, R34.2
DSI1_D2_P: J2.95, R22.1
DSI1_D3_N: J2.94, R35.2
DSI1_D3_P: J2.96, R23.1
ETH_0N: C70.2, J1.10, R75.1, U4.3 (TXRXM_A)
ETH_0P: C64.1, J1.12, R74.1, U4.2 (TXRXP_A)
ETH_1N: C74.2, J1.6, R77.1, U4.6 (TXRXM_B)
ETH_1P: C57.1, J1.4, R76.1, U4.5 (TXRXP_B)
ETH_2N: C73.2, J1.9, R85.1, U4.8 (TXRXM_C)
ETH_2P: C56.1, J1.11, R84.1, U4.7 (TXRXP_C)
ETH_3N: C68.2, J1.5, R87.1, U4.11 (TXRXM_D)
ETH_3P: C62.1, J1.3, R86.1, U4.10 (TXRXP_D)
ETH_INT_N: U1.M1 (PL89B), U4.38 (INT_N/PME_N2)
ETH_MDC: U1.J5 (PL50B), U4.36 (MDC)
ETH_MDIO: U1.E6 (PT6A), U4.37 (MDIO)
ETH_nLED1: J1.19, R72.1, U4.15 (LED2/PHYAD1)
ETH_nLED2: J1.17, R73.1, U4.17 (LED1/PHAD0/PME_N1)
ETH_~RESET: C101.1, R58.2, U1.G5 (PL41B), U4.42 (RESET_N)
FPDI_CLK+: C31.1, U1.J20 (PCLKT2_0)
FPDI_CLK-: C30.1, U1.K20 (PCLKC2_0)
FPDI_D0+: C33.1, U1.F17 (PR17A)
FPDI_D0-: C32.1, U1.G18 (PR17B)
FPDI_D1+: C35.1, U1.D18 (PR14A)
FPDI_D1-: C34.1, U1.E17 (PR14B)
FPDI_D2+: C37.1, U1.C18 (PR11A)
FPDI_D2-: C36.1, U1.D17 (PR11B)
GN0: C40.1, U1.C11 (PCLKC0_0)
GN3: C42.1, U1.C10 (PT58B)
GN4: C44.1, U1.A8 (PT18B)
GN5: C46.1, U1.B8 (PT15B)
GND: C1.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C38.2, C39.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C76.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, C94.1, C95.2, C96.2, C97.2, C98.2, C99.2, C100.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2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
GP0: C41.1, U1.B11 (PCLKT0_0)
GP3: C43.1, U1.B9 (PT58A)
GP4: C45.1, U1.A7 (PT18A)
GP5: C47.1, U1.C8 (PT15A)
GPIO2: J1.58, J1.69, U1.E14 (PT85B)
GPIO3: J1.56, J1.67, U1.B18 (PT116B)
GPIO4: J1.54, J1.63, U1.B15 (PT105A)
GPIO5: J1.34, U1.N1 (PL89D)
GPIO6: J1.30, U1.R1 (D7)
GPIO7: J1.37, U1.P3 (GPLL0T_IN)
GPIO8: J1.39, U1.P4 (GPLL0C_IN)
GPIO9: J1.40, U1.L5 (PL56D)
GPIO10: J1.44, U1.K4 (PL56A)
GPIO11: J1.38, U1.N2 (PL65A)
GPIO12: J1.31, J3.3, U1.R5 (TDI)
GPIO13: J1.28, U1.T1 (D6)
GPIO14: J1.55, J1.61, U1.P2 (PL92B)
GPIO15: J1.51, J1.57, U1.G1 (PCLKC6_0)
GPIO16: J1.29, J3.6, U1.V4 (TDO)
GPIO17: J1.50, U1.H3 (PL41D)
GPIO18: J1.49, U1.N5 (PL83B)
GPIO19: J1.26, U1.U1 (D5/MISO2)
GPIO20: J1.27, J3.4, U1.T5 (TCK)
GPIO21: J1.25, J3.5, U1.U5 (TMS)
GPIO22: J1.46, U1.M3 (PL86B)
GPIO23: J1.47, U1.N4 (PL83C)
GPIO24: J1.45, U1.N3 (PL86A)
GPIO25: J1.41, U1.P5 (PL83D)
GPIO26: J1.24, U1.V1 (D4/MOSI2)
GPIO27: J1.48, J1.62, U1.P1 (PL92A)
HDMI0_CEC: J2.51, R8.2
HDMI0_CLK_N: C30.2, J2.90
HDMI0_CLK_P: C31.2, J2.88
HDMI0_HOTPLUG: J2.53, R9.2
HDMI0_SCL: J2.100, R14.2
HDMI0_SDA: J2.99, R15.2
HDMI0_TX0_N: C32.2, J2.84
HDMI0_TX0_P: C33.2, J2.82
HDMI0_TX1_N: C34.2, J2.78
HDMI0_TX1_P: C35.2, J2.76
HDMI0_TX2_N: C36.2, J2.72
HDMI0_TX2_P: C37.2, J2.70
HDMI1_CEC: J2.49, R16.2
HDMI1_CLK_N: C40.2, J2.66
HDMI1_CLK_P: C41.2, J2.64
HDMI1_HOTPLUG: J2.43, R17.2
HDMI1_SCL: J2.47, R10.2
HDMI1_SDA: J2.45, R13.2
HDMI1_TX0_N: C42.2, J2.60
HDMI1_TX0_P: C43.2, J2.58
HDMI1_TX1_N: C44.2, J2.54
HDMI1_TX1_P: C45.2, J2.52
HDMI1_TX2_N: C46.2, J2.48
HDMI1_TX2_P: C47.2, J2.46
ID_SC: J1.35, U1.J3 (GR_PCLK6_1)
ID_SD: J1.36, U1.H1 (PL53C)
LED0: R40.1, U1.A3 (PL14C)
LED1: R41.1, U1.B3 (PL14D)
LED2: R42.1, U1.B2 (VREF1_7)
LED3: R43.1, U1.C3 (PL17C)
LED4: R44.1, U1.C2 (PL35D)
LED5: R45.1, U1.C1 (PL38A)
LED6: R46.1, U1.D1 (PL38B)
LED7: R47.1, U1.D3 (PL17D)
unnamed: BTN1.1, BTN2.1, BTN3.1, R18.1
unnamed: C94.2, R82.2, R83.1
unnamed: C109.1, C112.1, C115.1, FB1.2, U4.1 (AVDDH), U4.12 (AVDDH)
unnamed: D10.1 (K), R4.1
unnamed: D11.2 (A), R5.1
unnamed: D12.1 (K), R6.1
unnamed: D13.2 (A), R7.1
unnamed: R70.2, SW1.1, SW1.2
unnamed: RC1.1, RC2.2
unnamed: TP_E8.1, U1.E8 (PT13A)
unnamed: TP_E9.1, U1.E9 (PT20B)
unnamed: R26.2, U1.D12 (GR_PCLK1_0)
unnamed: R38.1, U1.E12 (GR_PCLK1_1)
unnamed: R25.2, U1.D13 (PT80A)
unnamed: R37.1, U1.E13 (PT80B)
unnamed: R24.2, U1.A14 (PT83A)
unnamed: R36.1, U1.C14 (PT83B)
unnamed: TP_C16.1, U1.C16 (PT112A)
unnamed: TP_D16.1, U1.D16 (PT112B)
unnamed: R23.2, U1.A18 (PT119A)
unnamed: R35.1, U1.B19 (PT119B)
unnamed: R22.2, U1.A19 (PT121A)
unnamed: R34.1, U1.B20 (PT121B)
unnamed: R81.1, U2.L8 (ZQ)
unnamed: R65.2, U4.48 (ISET)
PCIe_CLK_N: C66.2, J2.12
PCIe_CLK_P: C59.1, J2.10
PCIe_CLK_nREQ: J2.2, U1.A10 (PCLKT0_1)
PCIe_RX_N: C67.2, J2.18
PCIe_RX_P: C61.1, J2.16
PCIe_TX_N: C72.2, J2.24
PCIe_TX_P: C55.1, J2.22
PCIe_nRST: J2.9, TP_D8.1, U1.D8 (PT13B)
RGMII_RXD0: U1.K1 (PL53D), U4.32 (RXD0/MODE0)
RGMII_RXD1: U1.K2 (PL53A), U4.31 (RXD1/MODE1)
RGMII_RXD2: U1.L1 (PL65C), U4.28 (RXD2/MODE2)
RGMII_RXD3: U1.L2 (PL86D), U4.27 (RXD3/MODE3)
RGMII_RX_CLK: U1.H2 (PCLKT6_0), U4.35 (RX_CLK/PHYAD2)
RGMII_RX_DV: R71.1, U1.J1 (PL53B), U4.33 (RX_DV/CLK125_EN)
RGMII_TXD0: U1.K5 (VREF1_6), U4.19 (TXD0)
RGMII_TXD1: U1.J4 (GR_PCLK6_0), U4.20 (TXD1)
RGMII_TXD2: U1.L4 (PL56C), U4.21 (TXD2)
RGMII_TXD3: U1.L3 (PL86C), U4.22 (TXD3)
RGMII_TX_CLK: U1.H4 (GR_PCLK7_1), U4.24 (GTX_CLK)
RGMII_TX_EN: U1.K3 (PL50D), U4.25 (TX_EN)
SCL0: J1.80, U1.A12 (PT76A)
SDA0: J1.82, U1.A13 (PT76B)
SD_PWR_ON: J1.75, R20.1, U1.E15 (PT107B)
SW1: SW1.4, U1.C13 (PT78B)
SW2: SW1.3, U1.B13 (PT78A)
US2_ID: J2.1, P1.4 (ID), R19.1, U1.D9 (PT20A)
USB_FPGA_D+: D8.1 (K), R2.2, R4.2, R5.2, U1.A6 (PT4A), U1.F4 (PL20A)
USB_FPGA_D-: D9.1 (K), R1.2, R6.2, R7.2, U1.B6 (PT4B), U1.E3 (PL20B)
USB_FPGA_PULL_D+: D10.2 (A), D11.1 (K), U1.F5 (PL20D)
USB_FPGA_PULL_D-: D12.2 (A), D13.1 (K), U1.E5 (PL20C)
USB_N: J2.3, P1.2 (D-), R1.1
USB_P: J2.5, P1.3 (D+), R2.1
USER_PROGRAMN: D29.1 (K), U1.M4 (PL83A)
VCC1V2: 1.1V_1.1, C17.1, C27.1, C28.1, C99.1, C100.1, C102.1, C103.1, C104.1, C106.1, C108.1, C111.1, C114.1, FB2.2, FB3.2, RP1.2, U1.H8 (VCC), U1.H9 (VCC), U1.H10 (VCC), U1.H11 (VCC), U1.H12 (VCC), U1.H13 (VCC), U1.J8 (VCC), U1.J13 (VCC), U1.K8 (VCC), U1.K13 (VCC), U1.L8 (VCC), U1.L13 (VCC), U1.M8 (VCC), U1.M13 (VCC), U1.N8 (VCC), U1.N9 (VCC), U1.N10 (VCC), U1.N11 (VCC), U1.N12 (VCC), U1.N13 (VCC), U1.T6 (VCCA0), U1.T7 (VCCHTX0_D0CH0), U1.T8 (VCCHRX0_D0CH0), U1.T9 (VCCHRX0_D0CH1), U1.T10 (VCCHTX0_D0CH1), U1.T11 (VCCHTX0_D1CH0), U1.T12 (VCCHRX0_D1CH0), U1.T13 (VCCHRX0_D1CH1), U1.T14 (VCCHTX0_D1CH1), U1.T15 (VCCA1), U1.U6 (VCCA0), U1.U15 (VCCA1), U4.14 (DVDDL), U4.18 (DVDDL), U4.23 (DVDDL), U4.26 (DVDDL), U4.30 (DVDDL), U4.39 (DVDDL)
VCC1V35: C13.1, C25.1, C79.1, C80.1, C81.1, C82.1, C83.1, C84.1, C85.1, C86.1, C87.1, C89.1, C90.1, C91.1, C92.1, C98.1, R68.1, RP4.2, TP_1V35.1, U1.H14 (VCCio2), U1.H15 (VCCio2), U1.J15 (VCCio2), U1.L14 (VCCio3), U1.L15 (VCCio3), U1.M15 (VCCio3), U2.A1 (VddQ), U2.A8 (VddQ), U2.B2 (Vdd), U2.C1 (VddQ), U2.C9 (VddQ), U2.D2 (VddQ), U2.D9 (Vdd), U2.E9 (VddQ), U2.F1 (VddQ), U2.G7 (Vdd), U2.H2 (VddQ), U2.H9 (VddQ), U2.K2 (Vdd), U2.K8 (Vdd), U2.N1 (Vdd), U2.N9 (Vdd), U2.R1 (Vdd), U2.R9 (Vdd)

## KiCad design ulx3s.kicad_pcb

Board: 6 copper layers, 55.1 x 40.0 mm, 153 parts (90 on the bottom side), 220 nets.

Parts:
C1, C3, C4, C5, C7, C8, C9, C11, C12: 22uF; C_0603_1608Metric
C2, C6, C10: 100pF; C_0402_1005Metric
C13, C14, C15, C18, C21, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C54: 100n; C_0402_1005Metric
C16, C17, C19, C20, C22, C23, C24, C46, C47: 2.2uF; C_0603_1608Metric
C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35: 22nF; C_0402_1005Metric
C48, C49, C50, C51, C52, C53: 22nF; C_0603_1608Metric
C55, C56, C57, C58, C59, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75: 22n; C_0402_1005Metric
C60: 220nF; C_0402_1005Metric
D0: RED; LED_0603_1608Metric
D1: ORANGE; LED_0603_1608Metric
D2: GREEN; LED_0603_1608Metric
D3: BLUE; LED_0603_1608Metric
D4, D5, D6, D7, D17, D28, D29: 1N914; D_SOD-323
D8, D9: 3.6V; D_SOD-323_HandSoldering
H1, H2, H3, H4: HOLE; MountingHole_3.2mm_M3_ISO14580_Pad
IC1: VSC8530XMW-04; QFN40P600X600X90-49N-D
J1, J2: DF40C-100DP-0.4V(51); HRS_DF40C-100DP-0.4V(51)
J3: JTAG; PinSocket_2x03_P2.54mm_Vertical
L1, L2, L3: 2.2uH; L_1008_1210
R1, R2: 27; R_0402_1005Metric
R3, R30: 4.7k; C_0402_1005Metric
R4, R6: 1.1K; R_0402_1005Metric
R5, R7: 15K; R_0402_1005Metric
R8, R9, R16, R17: 100K; R_0402_1005Metric
R10, R13, R14, R15: 4K7; R_0402_1005Metric
R11, R12, R27, R28: 10k; C_0402_1005Metric
R18: 130; C_0402_1005Metric
R19, R20: 4.7K; R_0402_1005Metric
R29: 1.1k; C_0402_1005Metric
R31, R32, R33: 15k; C_0402_1005Metric
R41, R42, R43, R44: 549; C_0402_1005Metric
RA1, RA2, RA3: 15k; C_0402_1005Metric
RB1: 18k; C_0402_1005Metric
RB2: 4.7k; C_0402_1005Metric
RB3: 3.3k; C_0402_1005Metric
RP1, RP2, RP3: 0; R_0805_2012Metric_Pad1.29x1.40mm_HandSolder_Jumper_NC
RV2, RV3: 0; R_0805_2012Metric_Pad1.29x1.40mm_HandSolder
RX1: Antenna; PinHeader_1x02_P2.00mm_Vertical
SW1, SW2: SW_Push; Switch_EVPAA
TX1: Antenna; PinHeader_1x02_P2.00mm_Vertical
U1: LFE5U-85F-6BG381C; BGA-381_pitch0.8mm_dia0.4mm
U2: IS42S16320D-6BLI
U3, U4, U5: TLV62569DBV; TSOT-25
U10: IS25LP128F-JBLE; SOA008-150-208mil
Y1: FNETHE025; Crystal_SMD_TXC_7M-4Pin_3.2x2.5mm
radiona: radiona

Connections:
2V5_3V3: C26.1, C47.1, C48.1, C49.1, C53.1, RV2.2, RV3.1, U1.F9, U1.F10, U1.H6, U1.H7, U1.J6
+1V1: C17.1, C27.1, C28.1, RP1.2, U1.H8, U1.H9, U1.H10, U1.H11, U1.H12, U1.H13, U1.J8, U1.J13, U1.K8, U1.K13, U1.L8, U1.L13, U1.M8, U1.M13, U1.N8, U1.N9, U1.N10, U1.N11, U1.N12, U1.N13, U1.T6, U1.T7, U1.T8, U1.T9, U1.T10, U1.T11, U1.T12, U1.T13, U1.T14, U1.T15, U1.U6, U1.U15
+2V5: C19.1, C29.1, C30.1, RP2.2, RV2.1, U1.F6, U1.F15, U1.P6, U1.P15, U1.V10, U1.V11, U1.V17, U1.V18
+5V: C1.1, C5.1, C9.1, J1.77, J1.79, J1.81, J1.83, J1.85, J1.87, R3.1, R10.1, R13.1, R14.1, R15.1, U3.1, U3.4, U4.1, U4.4, U5.1, U5.4
/blinkey/ALED0: D0.2, R41.2
/blinkey/ALED1: D1.2, R42.2
/blinkey/ALED2: D2.2, R43.2
/blinkey/ALED3: D3.2, R44.2
/flash/FLASH_MISO: R28.2, U1.V2, U10.2
/flash/FLASH_MOSI: R27.2, U1.W2, U10.5
/flash/FLASH_SCK: R29.2, U1.U3, U10.6
/flash/FLASH_nCS: R30.2, U1.R2, U10.1
/flash/FLASH_nHOLD: R12.2, U1.W1, U10.7
/flash/FLASH_nWP: R11.2, U1.Y2, U10.3
/flash/FPGA_DONE: R32.2, U1.Y3
/flash/FPGA_INITN: R33.2, U1.V3
/flash/FPGA_PROGRAMN: D28.2, D29.2, R31.2, U1.W3
/power/FB1: C2.2, RA1.2, RB1.2, U3.5
/power/FB2: C10.2, RA2.2, RB2.2, U4.5
/power/FB3: C6.2, RA3.2, RB3.2, U5.5
/power/L1: L1.1, U3.3
/power/L2: L2.1, U4.3
/power/L3: L3.1, U5.3
/power/P1V1: C2.1, C3.1, C4.1, C22.1, L1.2, RA1.1, RP1.1
/power/P2V5: C10.1, C11.1, C12.1, C23.1, L2.2, RA2.1, RP2.1
/power/P3V3: C6.1, C7.1, C8.1, C24.1, L3.2, RA3.1, RP3.1
/serdes/CLK_0_N: C66.1, U1.Y12
/serdes/CLK_0_P: C59.2, U1.Y11
/serdes/CLK_1_N: C69.1, U1.W20
/serdes/CLK_1_P: C63.2, U1.Y19
/serdes/S_0_N: C67.1, U1.Y6
/serdes/S_0_P: C61.2, U1.Y5
/serdes/S_1_N: C68.1, U1.Y8
/serdes/S_1_P: C62.2, U1.Y7
/serdes/S_2_N: C72.1, U1.W5
/serdes/S_2_P: C55.2, U1.W4
/serdes/S_3_N: C73.1, U1.W9
/serdes/S_3_P: C56.2, U1.W8
/serdes/S_4_N: C70.1, U1.Y15
/serdes/S_4_P: C64.2, U1.Y14
/serdes/S_5_N: C71.1, RX1.1, U1.Y17
/serdes/S_5_P: C65.2, RX1.2, U1.Y16
/serdes/S_6_N: C74.1, U1.W14
/serdes/S_6_P: C57.2, U1.W13
/serdes/S_7_N: C75.1, TX1.1, U1.W18
/serdes/S_7_P: C58.2, TX1.2, U1.W17
BTN1: SW1.2, U1.C3
BTN2: SW2.2, U1.C2
CAM0_C_N: J2.40, U1.C12
CAM0_C_P: J2.42, U1.B12
CAM0_D0_N: J2.28, U1.A13
CAM0_D0_P: J2.30, U1.A12
CAM0_D1_N: J2.34, U1.C13
CAM0_D1_P: J2.36, U1.B13
CLK_25MHz: U1.G2, Y1.3
CM4_1.8V: J1.88, J1.90
CM4_3.3V: C16.1, C20.1, C25.1, C31.1, C32.1, C33.1, C34.1, C35.1, C46.1, C50.1, C51.1, C52.1, J1.84, J1.86, J3.2, R8.1, R11.1, R12.1, R16.1, R18.2, R19.1, R20.2, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, RP3.2, RV3.2, U1.F11, U1.F12, U1.H14, U1.H15, U1.J15, U1.L6, U1.L7, U1.L14, U1.L15, U1.M6, U1.M15, U1.P9, U1.P10, U1.T2, U1.T3, U1.T4, U1.U2, U2.A7, U2.A9, U2.B3, U2.C7, U2.D3, U2.E7, U2.J9, U10.8, Y1.1, Y1.4
Camera_GPIO: J1.97, U1.R18
DSI0_C_N: J2.69, U1.E12
DSI0_C_P: J2.71, U1.D12
DSI0_D0_N: J2.57, U1.E13
DSI0_D0_P: J2.59, U1.D13
DSI0_D1_N: J2.63, U1.C14
DSI0_D1_P: J2.65, U1.A14
DSI1_C_N: C69.2, J2.87
DSI1_C_P: C63.1, J2.89
DSI1_D0_N: C71.2, J2.75
DSI1_D0_P: C65.1, J2.77
DSI1_D1_N: C75.2, J2.81
DSI1_D1_P: C58.1, J2.83
DSI1_D2_N: J2.93, U1.B20
DSI1_D2_P: J2.95, U1.A19
DSI1_D3_N: J2.94, U1.B19
DSI1_D3_P: J2.96, U1.A18
ETH_0N: C70.2, J1.10
ETH_0P: C64.1, J1.12
ETH_1N: C74.2, J1.6
ETH_1P: C57.1, J1.4
ETH_2N: C73.2, J1.9
ETH_2P: C56.1, J1.11
ETH_3N: C68.2, J1.5
ETH_3P: C62.1, J1.3
FPDI_CLK+: C37.1, U1.J20
FPDI_CLK-: C38.1, U1.K20
FPDI_D0+: C21.1, U1.F17
FPDI_D0-: C36.1, U1.G18
FPDI_D1+: C15.1, U1.D18
FPDI_D1-: C18.1, U1.E17
FPDI_D2+: C13.1, U1.C18
FPDI_D2-: C14.1, U1.D17
GN0: C54.1, U1.C11
GN3: C44.1, U1.C10
GN4: C42.1, U1.A8
GN5: C40.1, U1.B8
GND: C1.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C11.2, C12.2, C16.2, C17.2, C19.2, C20.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C60.2, D0.1, D1.1, D2.1, D3.1, D8.2, D9.2, H1.1, H2.1, H3.1, H4.1, J1.1, J1.2, J1.7, J1.8, J1.13, J1.14, J1.22, J1.23, J1.32, J1.33, J1.42, J1.43, J1.52, J1.53, J1.59, J1.60, J1.65, J1.66, J1.71, J1.74, J1.98, J2.7, J2.8, J2.13, J2.14, J2.19, J2.20, J2.25, J2.26, J2.31, J2.32, J2.37, J2.38, J2.44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
GP0: C45.1, U1.B11
GP3: C43.1, U1.B9
GP4: C41.1, U1.A7
GP5: C39.1, U1.C8
GPIO2: J1.58, J1.69, U1.K1, U1.K5
GPIO3: J1.56, J1.67, U1.H1, U1.J5
GPIO4: J1.54, J1.63, U1.J3, U1.K4
GPIO5: J1.34, U1.H16
GPIO6: J1.30, U1.R1
GPIO7: J1.37, U1.P3
GPIO8: J1.39, U1.P4
GPIO9: J1.40, U1.G16
GPIO10: J1.44, U1.N17
GPIO11: J1.38, U1.L16
GPIO12: J1.31, J3.3, U1.R5
GPIO13: J1.28, U1.T1
GPIO14: J1.55, J1.61, U1.K2, U1.L4
GPIO15: J1.51, J1.57, U1.H2, U1.L5
GPIO16: J1.29, J3.6, U1.V4
GPIO17: J1.50, U1.M17
GPIO18: J1.49, U1.N5
GPIO19: J1.26, U1.U1
GPIO20: J1.27, J3.4, U1.T5
GPIO21: J1.25, J3.5, U1.U5
GPIO22: J1.46, U1.U18
GPIO23: J1.47, U1.N4
GPIO24: J1.45, U1.N3
GPIO25: J1.41, U1.P5
GPIO26: J1.24, U1.V1
GPIO27: J1.48, J1.62, U1.J1, U1.N16
HDMI0_CEC: J2.51, R8.2
HDMI0_CLK_N: C38.2, J2.90
HDMI0_CLK_P: C37.2, J2.88
HDMI0_HOTPLUG: J2.53, R9.2
HDMI0_SCL: J2.100, R14.2
HDMI0_SDA: J2.99, R15.2
HDMI0_TX0_N: C36.2, J2.84
HDMI0_TX0_P: C21.2, J2.82
HDMI0_TX1_N: C18.2, J2.78
HDMI0_TX1_P: C15.2, J2.76
HDMI0_TX2_N: C14.2, J2.72
HDMI0_TX2_P: C13.2, J2.70
HDMI1_CEC: J2.49, R16.2
HDMI1_CLK_N: C54.2, J2.66
HDMI1_CLK_P: C45.2, J2.64
HDMI1_HOTPLUG: J2.43, R17.2
HDMI1_SCL: J2.47, R10.2
HDMI1_SDA: J2.45, R13.2
HDMI1_TX0_N: C44.2, J2.60
HDMI1_TX0_P: C43.2, J2.58
HDMI1_TX1_N: C42.2, J2.54
HDMI1_TX1_P: C41.2, J2.52
HDMI1_TX2_N: C40.2, J2.48
HDMI1_TX2_P: C39.2, J2.46
ID_SC: J1.35, U1.R17
ID_SD: J1.36, U1.R16
LED0: R41.1, U1.B2
LED1: R42.1, U1.B1
LED2: R43.1, U1.B3
LED3: R44.1, U1.C1
unnamed: D4.1, R4.1
unnamed: D5.2, R5.1
unnamed: D6.1, R6.1
unnamed: D7.2, R7.1
unnamed: R18.1, SW1.1, SW2.1
PCIe_CLK_N: C66.2, J2.12
PCIe_CLK_P: C59.1, J2.10
PCIe_CLK_nREQ: J2.2, U1.A9
PCIe_RX_N: C67.2, J2.18
PCIe_RX_P: C61.1, J2.16
PCIe_TX_N: C72.2, J2.24
PCIe_TX_P: C55.1, J2.22
PCIe_nRST: J2.9, U1.D9
PWRBTn: C60.1, D17.1, D28.1, R3.2
SCL0: J1.80, U1.P16
SDA0: J1.82, U1.P17
SDRAM_A0: U1.L19, U2.H7
SDRAM_A1: U1.L20, U2.H8
SDRAM_A2: U1.M19, U2.J8
SDRAM_A3: U1.H17, U2.J7
SDRAM_A4: U1.F20, U2.J3
SDRAM_A5: U1.F18, U2.J2
SDRAM_A6: U1.E19, U2.H3
SDRAM_A7: U1.F19, U2.H2
SDRAM_A8: U1.E20, U2.H1
SDRAM_A9: U1.C20, U2.G3
SDRAM_A10: U1.N19, U2.H9
SDRAM_A11: U1.D20, U2.G2
SDRAM_A12: U1.E18, U2.G1
SDRAM_BA0: U1.L18, U2.G7
SDRAM_BA1: U1.M20, U2.G8
SDRAM_CKE: U1.G20, U2.F3
SDRAM_CLK: U1.G19, U2.F2
SDRAM_D0: U1.U20, U2.A8
SDRAM_D1: U1.T20, U2.B9
SDRAM_D2: U1.U19, U2.B8
SDRAM_D3: U1.T19, U2.C9
SDRAM_D4: U1.T18, U2.C8
SDRAM_D5: U1.T17, U2.D9
SDRAM_D6: U1.R20, U2.D8
SDRAM_D7: U1.P19, U2.E9
SDRAM_D8: U1.H20, U2.E1
SDRAM_D9: U1.J19, U2.D2
SDRAM_D10: U1.K18, U2.D1
SDRAM_D11: U1.J18, U2.C2
SDRAM_D12: U1.H18, U2.C1
SDRAM_D13: U1.J16, U2.B2
SDRAM_D14: U1.K19, U2.A2
SDRAM_D15: U1.J17, U2.B1
SDRAM_DQM0: U1.P20, U2.E8
SDRAM_DQM1: U1.D19, U2.F1
SDRAM_nCAS: U1.N18, U2.F7
SDRAM_nCS: U1.P18, U2.G9
SDRAM_nRAS: U1.M18, U2.F8
SDRAM_nWE: U1.N20, U2.F9
SD_PWR_ON: J1.75, R20.1, U1.U17
US2_ID: J2.1, R19.2, U1.A4
USB_FPGA_D+: D8.1, R2.2, R4.2, R5.2, U1.D15, U1.E16
USB_FPGA_D-: D9.1, R1.2, R6.2, R7.2, U1.E15, U1.F16
USB_FPGA_PULL_D+: D4.2, D5.1, U1.A2
USB_FPGA_PULL_D-: D6.2, D7.1, U1.A3
USB_N: J2.3, R1.1
USB_P: J2.5, R2.1
USER_PROGRAMN: D29.1, U1.M4
nEXTRST: J1.100, U1.U16

File 1-click-bom.tsv:

References,Qty,Description,Manufacturer,MPN,Manufacturer,MPN,Manufacturer,MPN,Manufacturer,MPN,Digikey,Mouser,RS,Newark,Farnell,LCSC,JLC Assembly
"C2, C6, C10",3,100pF,,04026C101KAT2A,AVX,04026C101KAT2A,,,,,478-12647-6-ND,58104026C101KAT2A,,,,,
"C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C55, C56, C57, C58, C59, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75",31,22nF,,04023D223KAT2A,KYOCERA AVX,04023D223KAT2A,,,,,478-10083-1-ND,58104023D223KAT2A,,,3288826,,
"C48, C49, C50, C51, C52, C53",6,22nF,,06033D223KAT2A,KYOCERA AVX,06033D223KAT2A,,,,,478-06033D223KAT2ATR-ND,58106033D223KAT2A,,,,,
"C13, C14, C15, C18, C21, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C54",16,100n,,0402YD104KAT2A,AVX,0402YD104KAT2A,,,,,478-1126-1-ND,5810402YD104K,6983197,,1327666,,
C60,1,220nF,,CGB2T3X5R0J224M022BB,TDK,CGB2T3X5R0J224M022BB,,,,,445-15613-1-ND,810CGB2T3X5R0J224MB,,,,,
"C16, C17, C19, C20, C22, C23, C24, C46, C47",9,2.2uF,,06033D225KAT2A,AVX,06033D225KAT2A,,,,,,58106033D225KAT2A,,,,,
"C1, C3, C4, C5, C7, C8, C9, C11, C12",9,22uF,,C0603C226M9PACTU,KEMET,C0603C226M9PACTU,,,,,,80C0603C226M9PACTU,,,3754565,,
RV3,1,0,,RC0805JR-070RL,Yageo,RC0805JR-070RL,Yageo,RC0805JR-070RP,Vishay,RCG08050000Z0EA,311-0.0ARCT-ND,603RC0805JR070RL,1995753,,1799478,,
"R1, R2",2,27,,RC0402FR-0727RL,Yageo,RC0402FR-0727RL,,,,,YAG3086DKR-ND,603RC0402FR0727RL,,,9239049,,
R18,1,130,,RC0402FR-07130RL,Yageo,RC0402FR-07130RL,,,,,311-130LRDKR-ND,603RC0402FR07130RL,,,3495526,,
"R41, R42, R43, R44",4,549,,RT0402BRD07549RL,Yageo,RT0402BRD07549RL,,,,,YAG4280DKR-ND,603RT0402BRD07549RL,,,,,
"R29, R4, R6",3,1.1k,,RC0402JR-071K1L,Yageo,RC0402JR-071K1L,,,,,311-1.1KJRCT-ND,603RC0402JR071K1L,,,,,
RB3,1,3.3k,,RC0402FR-073K3L,Yageo,RC0402FR-073K3L,,,,,311-3.30KLRCT-ND,603RC0402FR073K3L,1987781,,2693607,,
"R3, R30, RB2, R10, R13, R14, R15, R19, R20",9,4.7k,,RC0402JR-074K7L,Yageo,RC0402JR-074K7L,,,,,311-4.7KJRCT-ND,603RC0402JR074K7L,1987981,,9232842,,
"R11, R12, R27, R28",4,10k,,CRCW040210K0FKTD,Vishay,CRCW040210K0FKTD,,,,,541-2955-6-ND,71CRCW040210K,,,1652741RL,,
"R31, R32, R33, RA1, RA2, RA3, R5, R7",8,15k,,RMCF0402FT15K0,Stackpole Electronics,RMCF0402FT15K0,,,,,RMCF0402FT15K0CT-ND,,,,,,
RB1,1,18k,,RC0402FR-0718KL,Yageo,RC0402FR-0718KL,,,,,311-18.0KLRCT-ND,603RC0402FR0718KL,1987675,,9239383,,
"R8, R9, R16, R17",4,100k,,RMCF0402JT100K,Stackpole Electronics,RMCF0402JT100K,,,,,RMCF0402JT100KDKR-ND,,,,,,
"L1, L2, L3",3,2.2uH,,DFE322512F-2R2M=P2,Murata,DFE322512F-2R2M=P2,TDK,TFM322512ALMA2R2MTAA,,,445-TFM322512ALMA2R2MTAADKR-ND,81DFE322512F2R2MP2,,57AC6667,3490850,C285758,
"D4, D5, D6, D7, D17, D28, D29",7,1N914,,1N4148WS,Diotec,1N4148WS,onsemi,1N914BWS,Nexperia,BAS316Z,1N914BWSDKR-ND,5121N914BWS,,,2453274RL,,
"D8, D9",2,3.6V,,BZT52C3V6S,Rectron,BZT52C3V6S,MCC,BZT52C3V6S-TP,,,BZT52C3V6S-TPMSCT-ND,833BZT52C3V6STP,,,,,
D0,1,GREEN,,LTST-C190GKT,Lite-On,LTST-C190GKT,,,,,160-1183-2-ND,859LTSTC190GKT,6920975P,,,,
D1,1,BLUE,,LTST-C190TBKT,Lite-On,LTST-C190TBKT,,,,,160-1646-1-ND,859LTSTC190TBKT,6920994P,,,,
D2,1,GREEN,,LTST-C190GKT,Lite-On,LTST-C190GKT,,,,,160-1183-2-ND,859LTSTC190GKT,6920975P,,,,
D3,1,BLUE,,LTST-C190TBKT,Lite-On,LTST-C190TBKT,,,,,160-1646-1-ND,859LTSTC190TBKT,6920994P,,,,
U1,1,LFE5UM-85F-8BG381I,,LFE5UM-85F-8BG381I,Lattice Semiconductor,LFE5UM-85F-8BG381I,,,,,LFE5UM-85F-8BG381I-ND,842LFE5UM85F8BG381I,,,,,
U2,1,IS42S16320D-6BLI,,IS42S16320D-6BLI,ISSI,IS42S16320D-6BLI,,,,,IS42S16320D-6BLI-ND,870IS42S16320D6BLI,,,,,
"U3, U4, U5",3,TLV62569DBV,,TLV62569DBVR,Texas Instruments,TLV62569DBVR,,,,,296-47360-2-ND,595TLV62569DBVR,,,3121687,,
U10,1,W25Q128JVSIM,,W25Q128JVSIM,Winbond,W25Q128JVSIM,,,,,W25Q128JVSIM-ND,454W25Q128JVSIM,1882648P,,,,
Y1,1,FO3HSCBE25.0-T1,,FO3HSCBE25.0-T1,Fox Electronics,FO3HSCBE25.0-T1,,,,,631-1432-1-ND,ASE25.000MHZLCT,,,,,
"SW1, SW2",2,SW_Push,,R-667903,Mitsumi,R-667903,,,,,2508-R-667903CT-ND,,,,,,
"J1, J2",2,DF40C-100DP-0.4V(51),,798-DF40C100DP0.4V51,Hirose,DF40C-100DP-0.4V(51),,,,,H11614DKR-ND,798DF40C100DP0.4V51,,,2427678,,

Notices in the files:
ulx4m-ld.kicad_pcb:
License: CERN-OHL-S v2
parts and their libraries:
project_license: CERN-OHL-S v2

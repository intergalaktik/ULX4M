File: usb.sch (KiCad schematic (older format))
At the start: 16 parts, among them J3 JTAG, U1 LFE5U-85F-6BG381C, Y1 FNETHE025

Commit message: Fix #9 Cam0 and Cam1 are now true diff #6
Connections:
- net labels added: GPIO9, PCIe_CLK_nREQ
- wire segments 60 -> 61
Changed lines of the file:
@@
 Text GLabel 9300 4100 2    60   Input ~ 0
 JTAG_TMS
-Text GLabel 8650 1550 0    60   Input ~ 0
-SD_D0
-Text GLabel 10150 1750 2    60   Input ~ 0
-SD_D2
-Text GLabel 8650 1850 0    60   Input ~ 0
+Text GLabel 10150 2850 2    60   Input ~ 0
 SD_D3
-Text GLabel 8650 1350 0    60   Input ~ 0
+Text GLabel 10150 1350 2    60   Input ~ 0
 SD_CLK
-Text GLabel 10150 1850 2    60   Input ~ 0
+Text GLabel 8650 2850 0    60   Input ~ 0
 SD_CMD
 Text Notes 7200 3150 0    60   ~ 0
@@
 Wire Wire Line
 	5450 1200 5450 1250
-Text GLabel 8650 1750 0    60   Input ~ 0
-SD_D1
 Text Notes 750  6050 0    60   ~ 0
 Deviation from USB specification in\npulldowns for BOM simplificaton.\nWith series diode, correct value R63 R64 \nshould be 12k but 15k is used.
@@
 Text GLabel 10150 2250 2    60   Input ~ 0
 GPIO18
-Text GLabel 10150 1950 2    60   Input ~ 0
+Text GLabel 8225 1350 0    60   Input ~ 0
 GPIO15
 Text GLabel 8650 2150 0    60   Input ~ 0
@@
 Text GLabel 8650 2450 0    60   Input ~ 0
 GPIO24
-Text GLabel 8650 1950 0    60   Input ~ 0
+Text GLabel 8275 1950 0    60   Input ~ 0
 GPIO14
-Text GLabel 8650 2050 0    60   Input ~ 0
+Text GLabel 8275 2050 0    60   Input ~ 0
 GPIO4
-Text GLabel 10150 1650 2    60   Input ~ 0
+Text GLabel 10475 900  2    60   Input ~ 0
 GPIO3
-Text GLabel 10150 2050 2    60   Input ~ 0
+Text GLabel 10600 1750 2    60   Input ~ 0
 GPIO2
 Text GLabel 1375 2025 2    60   Input ~ 0
@@
 Wire Wire Line
 	975  2225 1075 2225
+Text GLabel 10375 1450 2    60   Input ~ 0
+PCIe_CLK_nREQ
+Wire Wire Line
+	10150 1450 10375 1450
+Text GLabel 10150 2650 2    60   Input ~ 0
+GPIO9
 $EndSCHEMATC

Commit message: Fix #12 If RC1 and RC2 are placed voltahe will be 1.2V
Parts:
- R19: value 4.7K -> 4k7
- R4, R6: value 1.1K -> 1k1
- R5, R7: value 15K -> 15k
Changed lines of the file:
@@
 P 2250 4700
 F 0 "R4" V 2300 4550 50  0000 C CNN
-F 1 "1.1K" V 2250 4700 39  0000 C CNN
+F 1 "1k1" V 2250 4700 39  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 2250 4700 50  0001 C CNN
 F 3 "~" H 2250 4700 50  0001 C CNN
@@
 P 2250 4850
 F 0 "R5" V 2300 4700 50  0000 C CNN
-F 1 "15K" V 2250 4850 39  0000 C CNN
+F 1 "15k" V 2250 4850 39  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 2250 4850 50  0001 C CNN
 F 3 "~" H 2250 4850 50  0001 C CNN
@@
 P 2300 5300
 F 0 "R6" V 2350 5150 50  0000 C CNN
-F 1 "1.1K" V 2300 5300 39  0000 C CNN
+F 1 "1k1" V 2300 5300 39  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 2300 5300 50  0001 C CNN
 F 3 "~" H 2300 5300 50  0001 C CNN
@@
 P 2300 5450
 F 0 "R7" V 2350 5300 50  0000 C CNN
-F 1 "15K" V 2300 5450 39  0000 C CNN
+F 1 "15k" V 2300 5450 39  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 2300 5450 50  0001 C CNN
 F 3 "~" H 2300 5450 50  0001 C CNN
@@
 P 1175 2225
 F 0 "R19" V 1225 2075 50  0000 C CNN
-F 1 "4.7K" V 1175 2225 39  0000 C CNN
+F 1 "4k7" V 1175 2225 39  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 1175 2225 50  0001 C CNN
 F 3 "~" H 1175 2225 50  0001 C CNN

Commit message: Adding 4 more LEDs - moving button
Parts:
- renumbered D4 to D10, D5 to D11, D6 to D12, D7 to D13
Connections:
- net labels removed: PCIe_CLK_nREQ
- wire segments 61 -> 60
Changed lines of the file:
@@
 $EndComp
 $Comp
-L Device:D_Small D5
+L Device:D_Small D11
 U 1 1 61604281
 P 1950 4850
-F 0 "D5" H 1750 4750 50  0000 C CNN
+F 0 "D11" H 1750 4750 50  0000 C CNN
 F 1 "1N914" H 1950 4750 50  0000 C CNN
 F 2 "Diode_SMD:D_SOD-323" V 1950 4850 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:D_Small D4
+L Device:D_Small D10
 U 1 1 6160522B
 P 1950 4700
-F 0 "D4" H 2150 4600 50  0000 C CNN
+F 0 "D10" H 2150 4600 50  0000 C CNN
 F 1 "1N914" H 1950 4584 50  0000 C CNN
 F 2 "Diode_SMD:D_SOD-323" V 1950 4700 50  0001 C CNN
@@
 Connection ~ 2450 4850
 $Comp
-L Device:D_Small D7
+L Device:D_Small D13
 U 1 1 616B7C2B
 P 2000 5450
-F 0 "D7" H 1800 5350 50  0000 C CNN
+F 0 "D13" H 1800 5350 50  0000 C CNN
 F 1 "1N914" H 2000 5350 50  0000 C CNN
 F 2 "Diode_SMD:D_SOD-323" V 2000 5450 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:D_Small D6
+L Device:D_Small D12
 U 1 1 616B7CCD
 P 2000 5300
-F 0 "D6" H 2200 5200 50  0000 C CNN
+F 0 "D12" H 2200 5200 50  0000 C CNN
 F 1 "1N914" H 2000 5184 50  0000 C CNN
 F 2 "Diode_SMD:D_SOD-323" V 2000 5300 50  0001 C CNN
@@
 Wire Wire Line
 	975  2225 1075 2225
-Text GLabel 10375 1450 2    60   Input ~ 0
-PCIe_CLK_nREQ
-Wire Wire Line
-	10150 1450 10375 1450
 Text GLabel 10150 2650 2    60   Input ~ 0
 GPIO9

Commit message: DDR3 lines are now around 10% - all GPIOs should be connected
Connections:
- net labels added: BTN3, GPIO11, GPIO22, GPIO5, ID_SC, ID_SD
Changed lines of the file:
@@
 Text GLabel 10150 2250 2    60   Input ~ 0
 GPIO18
-Text GLabel 8225 1350 0    60   Input ~ 0
+Text GLabel 10475 800  2    60   Input ~ 0
 GPIO15
 Text GLabel 8650 2150 0    60   Input ~ 0
@@
 Text GLabel 8650 2450 0    60   Input ~ 0
 GPIO24
-Text GLabel 8275 1950 0    60   Input ~ 0
+Text GLabel 10475 700  2    60   Input ~ 0
 GPIO14
-Text GLabel 8275 2050 0    60   Input ~ 0
+Text GLabel 10475 600  2    60   Input ~ 0
 GPIO4
 Text GLabel 10475 900  2    60   Input ~ 0
 GPIO3
-Text GLabel 10600 1750 2    60   Input ~ 0
+Text GLabel 10475 1000 2    60   Input ~ 0
 GPIO2
 Text GLabel 1375 2025 2    60   Input ~ 0
@@
 Text GLabel 10150 2650 2    60   Input ~ 0
 GPIO9
+Text GLabel 10150 1450 2    60   Input ~ 0
+BTN3
+Text GLabel 8650 1750 0    60   Input ~ 0
+ID_SD
+Text GLabel 8650 1350 0    60   Input ~ 0
+ID_SC
+Text GLabel 10150 2550 2    60   Input ~ 0
+GPIO5
+Text GLabel 8650 2650 0    60   Input ~ 0
+GPIO11
+Text GLabel 10150 2450 2    60   Input ~ 0
+GPIO22
 $EndSCHEMATC

Commit message: Initial complete routing done
Parts:
- J3: footprint Connector_PinSocket_2.54mm:PinSocket_2x03_P2.54mm_Vertical -> Connector_PinHeader_1.00mm:PinHeader_2x03_P1.00mm_Vertical_SMD
Connections:
- net labels added: ETH_INT_N, ETH_MDC, GPIO10, RGMII_REF_CLK, RGMII_RXD0, RGMII_RXD1, RGMII_RXD2, RGMII_RXD3, RGMII_RX_DV, RGMII_TXD0, RGMII_TXD1, RGMII_TXD2, RGMII_TXD3, RGMII_TX_EN
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 6 12
+Sheet 6 13
 Title "ULX3S"
 Date ""
@@
 F 0 "J3" H 7300 5717 50  0000 C CNN
 F 1 "JTAG" H 7300 5626 50  0000 C CNN
-F 2 "Connector_PinSocket_2.54mm:PinSocket_2x03_P2.54mm_Vertical" H 7250 5400 50  0001 C CNN
+F 2 "Connector_PinHeader_1.00mm:PinHeader_2x03_P1.00mm_Vertical_SMD" H 7250 5400 50  0001 C CNN
 F 3 "~" H 7250 5400 50  0001 C CNN
 	1    7250 5400
@@
 Wire Wire Line
 	975  2225 1075 2225
-Text GLabel 10150 2650 2    60   Input ~ 0
+Text GLabel 10150 1950 2    60   Input ~ 0
 GPIO9
 Text GLabel 10150 1450 2    60   Input ~ 0
@@
 Text GLabel 8650 1750 0    60   Input ~ 0
 ID_SD
-Text GLabel 8650 1350 0    60   Input ~ 0
+Text GLabel 8650 1550 0    60   Input ~ 0
 ID_SC
-Text GLabel 10150 2550 2    60   Input ~ 0
-GPIO5
 Text GLabel 8650 2650 0    60   Input ~ 0
 GPIO11
 Text GLabel 10150 2450 2    60   Input ~ 0
 GPIO22
+Text GLabel 10150 1650 2    50   Input ~ 0
+ETH_MDC
+Text GLabel 10150 1850 2    50   Output ~ 0
+RGMII_RX_DV
+Text GLabel 8650 1350 0    50   Output ~ 0
+RGMII_REF_CLK
+Text GLabel 10150 2650 2    50   Output ~ 0
+ETH_INT_N
+Text GLabel 8650 2550 0    50   Output ~ 0
+RGMII_RXD2
+Text GLabel 8650 1850 0    50   Output ~ 0
+RGMII_RXD1
+Text GLabel 10150 1750 2    50   Output ~ 0
+RGMII_RXD0
+Text GLabel 8650 2350 0    50   Input ~ 0
+RGMII_TXD3
+Text GLabel 8650 1950 0    50   Input ~ 0
+RGMII_TXD2
+Text GLabel 8650 1650 0    50   Input ~ 0
+RGMII_TXD1
+Text GLabel 10150 2050 2    50   Input ~ 0
+RGMII_TXD0
+Text GLabel 10150 2550 2    60   Input ~ 0
+GPIO5
+Text GLabel 10150 1550 2    50   Input ~ 0
+RGMII_TX_EN
+Text GLabel 10150 2350 2    50   Output ~ 0
+RGMII_RXD3
+Text GLabel 8650 2050 0    60   Input ~ 0
+GPIO10
 $EndSCHEMATC
